## pyappliance-br/Config.in
```kconfig
# Minimal BR2_EXTERNAL Config.in for pyappliance

menu "pyappliance external options"

endmenu
```
